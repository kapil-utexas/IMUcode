# Keil uVision project BlankPrj.uvprojx, settings and files
target Stm32F4Proj (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlankPrj
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1
  c include: .\CMSIS\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\Source;.\lib;.\board\inc;..\Libraries\CMSIS\Include;.\Source\board\src;.\STM32F4xx_StdPeriph_Driver\Include;.\STM32F4xx_StdPeriph_Driver\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Source/: startup_stm32f4xx.s stm32f4xx_it.c system_stm32f4xx.c main.c sysdelay.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_syscfg.c
  group board
    ./board/src/: led.c usart.c i2c.c retarget.c imu.c GPS_decode.c
  group fat
    ./board/src/: cc936.c sdio_sdcard.c ff.c fattester.c exfuns.c malloc.c diskio.c
